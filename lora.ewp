# IAR project lora.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L052R8 STM8L052R8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_HD_VL; DEBUG
  ICCSTM8.CCIncludePath2: inc; libs\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: lora.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group inc
    inc/: config.h init.h lora.h protocol.h stm8l15x_conf.h stm8l15x_it.h task.h uart.h
  group libs/inc
    libs/inc/: stm8l15x.h stm8l15x_adc.h stm8l15x_aes.h stm8l15x_beep.h stm8l15x_clk.h stm8l15x_comp.h stm8l15x_dac.h stm8l15x_dma.h stm8l15x_exti.h stm8l15x_flash.h stm8l15x_gpio.h stm8l15x_i2c.h stm8l15x_irtim.h stm8l15x_itc.h stm8l15x_iwdg.h stm8l15x_lcd.h stm8l15x_pwr.h stm8l15x_rst.h stm8l15x_rtc.h stm8l15x_spi.h stm8l15x_syscfg.h stm8l15x_tim1.h stm8l15x_tim2.h stm8l15x_tim3.h stm8l15x_tim4.h stm8l15x_tim5.h stm8l15x_usart.h stm8l15x_wfe.h stm8l15x_wwdg.h timing_delay.h
  group libs/src
    libs/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c timing_delay.c
  group src
    src/: at_cmd.c clock.c config.c data.c init.c protocol.c stm8l15x_it.c task.c uart.c
